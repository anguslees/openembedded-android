TOOLCHAIN_TARGET_TASK = "task-android-toolchain-target"
TOOLCHAIN_HOST_TASK = "task-android-toolchain-host"

require meta-toolchain.bb
SDK_SUFFIX = "toolchain-android"
